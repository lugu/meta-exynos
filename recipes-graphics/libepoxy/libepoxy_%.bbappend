PACKAGECONFIG_remove = "egl"
